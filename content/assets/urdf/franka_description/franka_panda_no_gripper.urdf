Commit message: Formatting all files to convention

File: content/assets/urdf/franka_description/franka_panda_no_gripper.urdf (robot description, URDF)
Before this commit: robot panda, 11 links, 10 joints
Joints:
- joint panda_fixed: origin xyz=0 0 0.0 rpy=0 0 0.0 -> xyz=0 0 0.0 rpy=0 0 0.7853982
