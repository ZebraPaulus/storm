Commit message: Refactoring setup and setting ball straight.

File: content/assets/urdf/ball/movable_ball.urdf (robot description, URDF)
Before this commit: robot ball, 7 links, 6 joints
Joints:
- joint rx_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=1.57079 0 0
